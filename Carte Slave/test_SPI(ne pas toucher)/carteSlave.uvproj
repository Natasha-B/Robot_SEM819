# Keil uVision project carteSlave.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: carteSlave
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 C8051F020.h pointeur lumineux.c pointeur.h slave_main.c UART0.c SPI_slave.c information.c information.h
