# Keil uVision project Projet_BSE.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Projet_BSE
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Binome_B.c Binome_B.h Main_BSE56.c c8051F020.h Binome_A.c Binome_A.h
